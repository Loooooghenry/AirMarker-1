# Keil uVision project ble_app_uart_c_s120_spi_pca10028.uvprojx, settings and files
target nrf51422_xxac_s120 (ARM-ADS)
  device: nRF51422_xxAC Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.2.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(16000000) ELITTLE
  output: nrf51422_xxac_s120 +hex
  c flags: Optim=4 OneElfS=1
  c define: SPI_MASTER_0_ENABLE BLE_STACK_SUPPORT_REQD SWI_DISABLE3 SVCALL_AS_NORMAL_FUNCTION S120 BOARD_PCA10028 BSP_UART_SUPPORT NRF51 SWI_DISABLE0
  c misc: --c99
  asm define: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application
    ../../../: main.c
  group Documentation
    ../../../: Abstract.txt license.txt
target flash_s120_nrf51_2.1.0_softdevice (ARM-ADS)
  device: nRF51422_xxAC Nordic Semiconductor
  pack: ..
  cpu: as above
  output: s120_nrf51_2.1.0_softdevice.hex +hex
  c flags: Optim=4 OneElfS=1
  c define: SPI_MASTER_0_ENABLE BLE_STACK_SUPPORT_REQD NRF51
  c misc: --c99
  asm define: SPI_MASTER_0_ENABLE BLE_STACK_SUPPORT_REQD NRF51
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
software components: CMSIS:CORE 4.3.0, Device:Startup 8.2.0, nRF_Libraries:app_button 3.1.0, nRF_Drivers:nrf_delay 3.1.0, nRF_Drivers:nrf_gpio 3.1.0, nRF_Serialization:Internal:serapp_codecs_s120_ble_gattc_evt 2.1.0, nRF_Libraries:app_error 3.1.0, nRF_Serialization:Internal:cond_field_serialization 2.1.0, nRF_Drivers:nrf_drv_spi 3.1.0, nRF_Serialization:Internal:serapp_codecs_s120_ble_evt_mux 2.1.0, nRF_Serialization:Internal:serapp_codecs_s120_nrf_soc 2.1.0, nRF_Drivers:nrf_gpiote 3.1.0, nRF_Serialization:Internal:ser_softdevice_handler 2.1.0, nRF_Serialization:Internal:serapp_codecs_s120_ble 2.1.0, nRF_Serialization:Internal:serapp_codecs_s120_ble_l2cap_evt 2.1.0, nRF_Serialization:Internal:ser_hal_transport 2.1.0, nRF_Drivers:nrf_error 3.1.0, nRF_Libraries:app_scheduler 3.1.0, nRF_Drivers:nrf_spi 3.1.0, nRF_BLE:BLE_Modules:ble_service_common 3.1.0, Board Support:bsp_btn_ble 10.0.0, nRF_Serialization:ser_phy 2.1.0, nRF_Drivers:nrf_spim 3.1.0, nRF_Serialization:Internal:serapp_codecs_s120_ble_gap_evt 2.1.0, nRF_Drivers:nrf_uarte 3.1.0, nRF_Serialization:Internal:serapp_codecs_s120_ble_gap 2.1.0, nRF_Serialization:Internal:serapp_codecs_s120_ble_gattc 2.1.0, nRF_Serialization:Internal:serapp_mw_s120 2.1.0, nRF_Serialization:Internal:ser_app_hal 2.1.0, Board Support:bsp 10.0.0, nRF_Serialization:Internal:ser_codecs_s120_ble_gatts_struct 2.1.0, nRF_Libraries:retarget 3.1.0, nRF_Serialization:Internal:ser_codecs_s120_ble_gap_struct 2.1.0, nRF_Libraries:app_fifo 3.1.0, nRF_BLE:BLE_Services:ble_nus_c 3.1.0, nRF_SoftDevice:s120_hex 2.1.1, nRF_Libraries:nrf_assert 3.1.0, nRF_Serialization:Internal:serapp_codecs_s120_ble_gatts 2.1.0, nRF_Serialization:Internal:ser_sd_transport 2.1.0, nRF_BLE:BLE_Modules:ble_db_discovery 3.1.0, nRF_Serialization:Internal:ser_codecs_common 2.1.0, nRF_Drivers:nrf_drv_uart 3.1.0, nRF_Libraries:app_util 3.1.0, nRF_Serialization:Internal:serapp_s120 2.1.0, nRF_Serialization:Internal:serapp_codecs_s120_ble_l2cap 2.1.0, nRF_SoftDevice:Internal:sd_common 1.1.5, nRF_Serialization:Internal:serapp_codecs_s120_ble_gatts_evt 2.1.0, nRF_Libraries:app_trace 3.1.0, nRF_SoftDevice:s120 2.1.1, nRF_Serialization:Internal:serapp_hal_power_system_off 2.1.0, nRF_Drivers:nrf_soc 3.1.0, nRF_Drivers:nrf_drv_gpiote 3.1.0, nRF_Drivers:nrf_uart 3.1.0, nRF_Drivers:nrf_drv_common 3.1.0, nRF_Libraries:nordic_common 3.1.0, nRF_Libraries:app_timer 3.1.0, nRF_Libraries:Internal:app_mailbox 3.1.0, nRF_Drivers:app_uart 3.1.0, nRF_BLE:BLE_Modules:ble_advdata 3.1.0, nRF_Serialization:Internal:ser_codecs_s120_ble_gattc_struct 2.1.0, nRF_Serialization:Internal:ser_codecs_s120_ble_struct 2.1.0

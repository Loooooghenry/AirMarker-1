# Keil uVision project ble_app_uart_s110_pca20006.uvprojx, settings and files
target nrf51422_xxac_s110 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.2.0
  cpu: IRAM(0x20000000,0x4000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: nrf51422_xxac_s110 +hex
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1
  c define: BLE_STACK_SUPPORT_REQD BOARD_PCA20006 S110 NRF51 SOFTDEVICE_PRESENT SWI_DISABLE0
  c misc: --c99
  asm define: BLE_STACK_SUPPORT_REQD BOARD_PCA10028 S110 NRF51 SOFTDEVICE_PRESENT SWI_DISABLE0
  library: MicroLIB
  memory RVCT4: ROM 0x18000 size 0x28000
  memory RVCT9: RAM 0x20002000 size 0x6000
  group Application
    ../../../: main.c
  group Documentation
    ../../../: Abstract.txt license.txt
target flash_s110_nrf51_8.0.0_softdevice (ARM-ADS)
  device: nRF51422_xxAC Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.2.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(16000000) ELITTLE
  output: s110_nrf51_8.0.0_softdevice.hex +hex
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1
  c define: BLE_STACK_SUPPORT_REQD NRF51
  c misc: --c99
  asm define: BLE_STACK_SUPPORT_REQD NRF51
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
software components: CMSIS:CORE 4.3.0, Board Support:bsp 10.0.0, Board Support:bsp_btn_ble 10.0.0, Device:Startup 8.2.0, nRF_BLE:BLE_Modules:ble_advdata 3.1.0, nRF_BLE:BLE_Modules:ble_advertising 3.1.0, nRF_BLE:BLE_Modules:ble_common 3.1.0, nRF_BLE:BLE_Modules:ble_conn_params 3.1.0, nRF_BLE:BLE_Modules:ble_service_common 3.1.0, nRF_BLE:BLE_Services:ble_nus 3.1.0, nRF_Drivers:app_uart 3.1.0, nRF_Drivers:nrf_delay 3.1.0, nRF_Drivers:nrf_drv_common 3.1.0, nRF_Drivers:nrf_drv_gpiote 3.1.0, nRF_Drivers:nrf_drv_uart 3.1.0, nRF_Drivers:nrf_error 3.1.0, nRF_Drivers:nrf_gpio 3.1.0, nRF_Drivers:nrf_gpiote 3.1.0, nRF_Drivers:nrf_uart 3.1.0, nRF_Drivers:nrf_uarte 3.1.0, nRF_Drivers:pstorage 3.1.0, nRF_Libraries:app_button 3.1.0, nRF_Libraries:app_error 3.1.0, nRF_Libraries:app_fifo 3.1.0, nRF_Libraries:app_timer 3.1.0, nRF_Libraries:app_trace 3.1.0, nRF_Libraries:app_util 3.1.0, nRF_Libraries:nordic_common 3.1.0, nRF_Libraries:nrf_assert 3.1.0, nRF_Libraries:retarget 3.1.0, nRF_SoftDevice:Internal:sd_common 1.1.5, nRF_SoftDevice:Internal:softdevice_present 1.1.5, nRF_SoftDevice:s110 8.0.3, nRF_SoftDevice:s110_hex 8.0.3
